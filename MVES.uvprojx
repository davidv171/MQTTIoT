# Keil uVision project MVES.uvprojx, settings and files
target FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAM4SD32C Atmel
  pack: Keil.SAM4_DFP.1.4.0
  cpu: IROM(0x00400000,0x100000) IROM2(0x00500000,0x100000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: VES
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source
    ./: main.c hw_util.c
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Device:Startup 1.1.1
